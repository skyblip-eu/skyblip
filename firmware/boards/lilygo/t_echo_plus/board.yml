## firmware/boards/lilygo/t_echo_plus/board.yml
```yaml
board:
  name: t_echo_plus
  full_name: LilyGO T-Echo Plus (skyBlip Go)
  vendor: lilygo
  socs:
    - name: nrf52840
```
